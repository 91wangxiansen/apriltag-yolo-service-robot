# Keil uVision project huanyu_slam_base.uvprojx, settings and files
target Huanyu_Slam (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: huanyu_slam_base +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\HARDWARE\Delay;..\HARDWARE\Encoder;..\HARDWARE\Gpio;..\HARDWARE\Led;..\HARDWARE\Moto;..\HARDWARE\Sys;..\HARDWARE\Times;..\HARDWARE\Usart;..\HARDWARE\pid;..\HARDWARE\IIc;..\HARDWARE\Mpu;..\HARDWARE\Chrg;..\HARDWARE\Iwdg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_iwdg.c
  group HARDWARE
    ../HARDWARE/Delay/: Huanyu_delay.c
    ../HARDWARE/Led/: Huanyu_led.c
    ../HARDWARE/Sys/: Huanyu_sys.c
    ../HARDWARE/Times/: Huanyu_time.c
    ../HARDWARE/Usart/: Huanyu_usart.c
    ../HARDWARE/Encoder/: Huanyu_encoder.c
    ../HARDWARE/Moto/: Huanyu_moto.c
    ../HARDWARE/pid/: Huanyu_pid.c
    ../HARDWARE/IIc/: Huanyu_iic.c
    ../HARDWARE/Mpu/: Huanyu_mpu6050.c
    ../HARDWARE/Chrg/: Huanyu_charge.c
    ../HARDWARE/Iwdg/: Huanyu_iwdg.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
